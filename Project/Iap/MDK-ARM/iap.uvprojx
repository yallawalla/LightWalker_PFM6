# Keil uVision project iap.uvprojx, settings and files
target iap...PFM6 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F405VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: iapPFM6 +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,__PFM6__,HSE_VALUE=25000000,WITH_COM_PORT
  c include: ..\;..\Inc;..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include;..\..\Pfm6Ctrl\inc\app;..\..\Pfm6Ctrl\src\wifi;..\..\..\Utilities\FatFs_R0.09a
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../Src/: main.c
  group Serial
    ../Src/: serial.c usart.c io.c led.c
  group stm32f2xx StdPeriph_Driver
    ../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_gpio.c stm32f2xx_iwdg.c stm32f2xx_rcc.c stm32f2xx_usart.c stm32f2xx_flash.c misc.c stm32f2xx_dma.c
  group Startup 205
    ../Src/: startup_stm32f2xx.s system_stm32f2xx.c
  group FatFs
    ../../../Utilities/FatFs_R0.09a/: diskio.c ff.c
    ../../../Utilities/FatFs_R0.09a/option/: ccsbcs.c
target iap...PFM8 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F205VC STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: iapPFM8 +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,__PFM8__,HSE_VALUE=8000000,WITH_COM_PORT
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
target iap...Discovery (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F205VC STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: as above
  output: iapDiscovery +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_USB_OTG_FS,__DISCO__,HSE_VALUE=8000000,WITH_COM_PORT
  c include: ..\;..\Inc;..\..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include;..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\Pfm6Ctrl\inc\app;..\..\..\Utilities\FatFs_R0.09a
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
target IOC_v1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F205VGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: iapIOCv1 +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,__IOCV1__,HSE_VALUE=25000000,WITH_COM_PORT
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
target IOC_v2 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F405VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: as above
  output: iapIOCv2 +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,__IOCV2__,HSE_VALUE=8000000,WITH_COM_PORT
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target Nucleo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F405VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: as above
  output: iapIOCv2 +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,__NUCLEO__,HSE_VALUE=8000000,WITH_COM_PORT
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.0.1
